# IAR project FMC.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M051DN series Nuvoton M051DN series (M052DN,M054DN,M058DN,M0516DN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M051Series\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\M051-LB_004\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FMC.bin
  ILINK.IlinkOutputFile: FMC.out
  ILINK.IlinkIcfFile: FMC.icf
  ILINK.IlinkExtraOptions: --image_input Release\Exe\FMC_LD.bin,g_u32LoaderImageBase,.bin_image,4; --image_input Release\Exe\FMC_LD.bin,g_u32LoaderImageLimit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M051Series/Source/IAR/: startup_M051Series.s
    ../../../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group Library
    ../../../../Library/M051-LB_004/src/: Ascii_Table.C lcd_driver.c
    ../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c
